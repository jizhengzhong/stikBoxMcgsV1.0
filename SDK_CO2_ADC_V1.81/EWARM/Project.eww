<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SDK_CO2_TEMP.ewp</path>
  </project>
  <batchBuild />
</workspace>
