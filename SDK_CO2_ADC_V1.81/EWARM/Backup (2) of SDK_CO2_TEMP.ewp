# IAR project Backup (2) of SDK_CO2_TEMP.ewp, settings and files
configuration SDK_CO2_TEMP (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427VG ST STM32F427VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F427xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Include; ..\CMSISOS\Config; ..\CMSISOS\Include; ..\CMSISOS\Source; ..\APP; ..\modbus; ..\print
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SDK_CO2_TEMP.srec
  ILINK.IlinkOutputFile: SDK_CO2_TEMP.out
  ILINK.IlinkIcfFile: stm32f427xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ../APP/: alspi.c appcfg.h appmanage.c control.cpp delay.c iichal.c ledctr.c malloc.c myiic.c osObjCreat.c osObjects.h partab.c pincfg.h sd_lpc.c strctr.c sys.c sysfun.c systask.c
  group Application/EWARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group CMSIS-OS/CFG
    ../CMSISOS/Config/: cmsis_os1.c os_systick.c RTX_Config.c RTX_Config.h
  group CMSIS-OS/HAL
    ../CMSISOS/Source/IAR/: irq_cm4f.s
  group CMSIS-OS/SRC
    ../CMSISOS/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
  group COM/GPRS
    ../gprs/: gprsapi.c gprsapp.c gprscom.c
  group COM/PRINT
    ../print/: printapp.c printcom.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_gpio.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c
  group Middlewares
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c
  group MOSBUS
    ../modbus/: mbapp.c mbdatacb.c mbossync.c mbportx.c mbporty.c mbportz.c modbus_lib_m4.a
  group MUSIC
    ../wavtask/: audioplay.c audioplay.h i2s.c wavplay.c wavplay.h wm8978.c wm8978.h
  group README
    ../APP/: read_me.txt
